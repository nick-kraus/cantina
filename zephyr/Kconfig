## zephyr/Kconfig
```kconfig
menu "CANtina"

config CANTINA
    bool
    help
        Enable support for the CANtina CANopen stack

endmenu
```
